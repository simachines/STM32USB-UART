<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F401 USB-UART Bridge PAssthrough.ewp</path>
  </project>
  <batchBuild />
</workspace>
